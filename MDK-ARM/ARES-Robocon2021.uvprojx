# Keil uVision project ARES-Robocon2021.uvprojx, settings and files
target ARES-Robocon2021 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ARES-Robocon2021 +hex
  c flags: Optim=1 oTime=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx, ARM_MATH_CM4,__TARGET_FPU_VFP=1
  c include: ../Core/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ..\DSP\Include; ..\Drivers\CMSIS\DSP\Include; ../Middlewares/ST/STM32_MotionFX_Library/Inc; ../Middlewares/ST/STM32_MotionMC_Library/Inc; ..\ARES\Application\INS_task; ..\ARES\Application\motor_task; ..\ARES\Application\state_steaming; ..\ARES\Application\user_init; ..\ARES\Application\feedback_task; ..\ARES\Application\monitor_task; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ..\ARES\Application\quick_test_task; ..\ARES\Application\chassis_task; ..\ARES\Application\computer_task; ..\ARES\Driver\Components\steer; ..\ARES\Driver\OffBoard\encoder; ..\ARES\Driver\OffBoard\mcp2515; ..\ARES\Driver\OffBoard\motor; ..\ARES\Driver\OffBoard\ops; ..\ARES\Driver\OffBoard\sbus; ..\ARES\Driver\OnBoard\can_comm; ..\ARES\Driver\OnBoard\flash; ..\ARES\Driver\OnBoard\imu; ..\ARES\Utils\algorithm; ..\ARES\Utils\controller; ..\ARES\Utils\cpu_utils; ..\ARES\Utils\stopwatch; ..\ARES\Driver\Components\swerve; ..\ARES\Driver\OffBoard\interboard_spi; ..\ARES\Driver\OnBoard\pwm_input; ..\ARES\Driver\OffBoard\servo; ..\ARES\Driver\OffBoard\computer; ..\ARES\Utils\fsm
  asm include: ..\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c crc.c dma.c rng.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/STM32_MotionFX_Library/Sensors/STM32_MotionFX_Library/Core
    ../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc16_ot.a
  group Middlewares/STM32_MotionMC_Library/Sensors/STM32_MotionMC_Library/Core
    ../Middlewares/ST/STM32_MotionMC_Library/Lib/: MotionMC_CM4F_wc16_ot.a
  group ARES/Application
    ../ARES/Application/INS_task/: INS_task.c
    ../ARES/Application/motor_task/: motor_task.c
    ../ARES/Application/user_init/: user_init.c
    ../ARES/Application/feedback_task/: feedback_task.c
    ../ARES/Application/quick_test_task/: quick_test_task.c
    ../ARES/Application/monitor_task/: monitor_task.c
    ../ARES/Application/computer_task/: computer_task.c
    ../ARES/Application/chassis_task/: tr_chassis.c dr_chassis.c
  group ARES/Dirvers/Component
    ../ARES/Driver/Components/steer/: steer.c
    ../ARES/Driver/Components/swerve/: swerve.c
  group ARES/Drivers/OnBoard
    ../ARES/Driver/OnBoard/: user_it.c
    ../ARES/Driver/OnBoard/can_comm/: can_comm.c
    ../ARES/Driver/OnBoard/flash/: flash_io.c
    ../ARES/Driver/OnBoard/imu/: imu.c imu_comm.c
    ../ARES/Driver/OnBoard/pwm_input/: pwm_input.c
  group ARES/Drivers/OffBoard
    ../ARES/Driver/OffBoard/motor/: motor.c rmd_motor.c rm_motor.c vesc_motor.c
    ../ARES/Driver/OffBoard/ops/: ops.c
    ../ARES/Driver/OffBoard/sbus/: sbus.c
    ../ARES/Driver/OffBoard/interboard_spi/: interboard_spi.c
    ../ARES/Driver/OffBoard/servo/: servo.c
    ../ARES/Driver/OffBoard/encoder/: can_encoder.c pwm_encoder.c
    ../ARES/Driver/OffBoard/computer/: computer_usb.c
  group ARES/Utils
    ../ARES/Utils/algorithm/: quintic_trajectory.c user_lib.c bezier_trajectory.c
    ../ARES/Utils/controller/: controller.c FSF.c PID.c ADRC.c
    ../ARES/Utils/cpu_utils/: cpu_utils.c
    ../ARES/Utils/stopwatch/: stopwatch.c
    ../ARES/Utils/fsm/: fsm.c
software components: CMSIS:CORE 5.4.0, CMSIS:DSP 1.8.0
